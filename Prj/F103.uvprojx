# Keil uVision project F103.uvprojx, settings and files
target MPU6050 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: F103 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER  STM32F10X_HD
  c include: ..\CMSIS;..\Device;..\Drivers;..\Libraries\inc;..\Users
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Users
    ../Users/: main.c DMA.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
  group Drivers
    ../Drivers/: bsp.c stm32f10x_it.c delay.c printf.c mymath.c
  group Libraries
    ../Libraries/src/: misc.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_dma.c stm32f10x_adc.c
  group Devices
    ../Device/: usart.c adc.c bsp_i2c.c mpu6050.c
software components: CMSIS:CORE 4.3.0
